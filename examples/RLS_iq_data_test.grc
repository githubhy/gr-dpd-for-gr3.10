options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fl/gr-dpd/examples/Data_Files/Input.bin
    repeat: 'True'
    type: complex
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1, 1, 1, 1, 1, 1, 1, 1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_GMP_model_PA_1
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1, 1, 1, 1, 1, 1, 1, 1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_RLS_postdistorter_0
  id: dpd_RLS_postdistorter
  parameters:
    dpd_params: (3, 3, 1, 1, 1)
    iter_limit: '400'
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    dpd_params: (3,3,1,1,1)
    mode: training
    tap: (1)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"green"'
    color3: '"blue"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    label1: PA_DPD
    label2: PA_without_DPD
    label3: Predistorter_out
    label4: Input
    name: '"PA_with_DPD"'
    nconnections: '4'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', dpd_GMP_model_PA_1, '0']
- [blocks_file_source_0, '0', dpd_gain_phase_calibrate_0, '1']
- [blocks_file_source_0, '0', dpd_predistorter_training_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '3']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '2']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_0, '0']
- [dpd_GMP_model_PA_1, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_1, '0', qtgui_freq_sink_x_0, '1']
- [dpd_RLS_postdistorter_0, taps, dpd_predistorter_training_0, taps]
- [dpd_gain_phase_calibrate_0, '0', dpd_RLS_postdistorter_0, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']
- [dpd_predistorter_training_0, '0', dpd_RLS_postdistorter_0, '1']
- [dpd_predistorter_training_0, '0', qtgui_freq_sink_x_0, '2']
- [dpd_predistorter_training_0, '1', dpd_RLS_postdistorter_0, '2']

metadata:
  file_format: 1
